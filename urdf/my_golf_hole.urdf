Commit message: Adding agent, buffer class, checkpoint for proba1 file

File: urdf/my_golf_hole.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: mass 1.0 -> None; geometry visual cylinder length=0.02 radius=0.05
